# Keil uVision project Lab9.uvproj, settings and files
target Lab9 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Blynk
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..;.\Include;.\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Library
    ./Library/: PLL.c PortF.c ST7735.c startup.s Timer2.c Timer3.c UART.c IO.s LCD.s
  group Source
    ./Source/: Debug.c Graphics.c Main.c Timer.c ADC.c
  group Include
    ./Include/: Debug.h Graphics.h Timer.h ADC.h
